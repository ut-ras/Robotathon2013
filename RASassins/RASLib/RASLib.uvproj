# Keil uVision project RASLib.uvproj, settings and files
target RASLib (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: RASLib (library)
  c define: rvmdk PART_LM4F120H5QR TARGET_IS_BLIZZARD_RA1
  c include: ..\;C:\;..\StellarisWare;C:\StellarisWare;inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./src/: Startup.s motor.c servo.c adc.c time.c uart.c encoder.c gpio.c pwm.c sonar.c i2c.c linesensor.c common.c i2clinesensor.c gpiolinesensor.c
  group Libraries
    C:/StellarisWare/driverlib/rvmdk-cm4f/: driverlib-cm4f.lib
